require recipes-security/optee/optee-os-fio.inc


OPTEE_OS_REPO = "git://github.com/MrCry0/optee_os.git"
SRCREV = "76aa53bfb27faf7c3ac841f02f9f04c670c694bf"
SRCBRANCH = "3.21+fio-imx"

DEFAULT_PREFERENCE = "-1"
