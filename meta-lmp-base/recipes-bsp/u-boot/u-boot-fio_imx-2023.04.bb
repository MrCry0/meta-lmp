require u-boot-fio-common.inc

UBOOT_REPO = "git://github.com/MrCry0/u-boot.git"
SRCREV = "${AUTOREV}"
SRCBRANCH = "2023.04+lf-6.1.22-2.0.0-fio-debug"
LIC_FILES_CHKSUM = "file://Licenses/README;md5=2ca5f2c35c8cc335f0a19756634782f1"

DEFAULT_PREFERENCE = "-1"
