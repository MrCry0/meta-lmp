require optee-os-fio.inc

OPTEE_OS_REPO = "git://github.com/MrCry0/optee_os.git"
SRCREV = "2921ce9ecbd28a50bb2cb936bf7272c8d6e9e577"
SRCBRANCH = "3.21+fio"
